# Keil uVision project application.uvprojx, settings and files
target STM32F429I_DISCO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429ZI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429I_DISCO +hex
  c flags: Optim=1 wLevel=2
  c define: ST STM32F429xx USE_STM32F429I_DISCO USE_STDPERIPH_DRIVER HSE_VALUE=8000000 USE_BPP=16 USE_OS_SYSTICK
  c include: ..\TouchGFX\gui\include;..\TouchGFX\target\include;..\TouchGFX\platform\os;..\TouchGFX\generated\fonts\include;..\TouchGFX\generated\images\include;..\TouchGFX\generated\texts\include;..\TouchGFX\generated\gui_generated\include;../../middlewares/st/touchgfx/touchgfx/framework/include;..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\BSP\STM32F429I-Discovery;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32f4xx\Include;..\TouchGFX\target;..\Core\Inc;..\..\Middlewares\AcDimmerLib
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F429I_DISCO
    ../../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery_ts.c stm32f429i_discovery.c stm32f429i_discovery_eeprom.c stm32f429i_discovery_io.c stm32f429i_discovery_sdram.c
  group Example/User
    ../Core/Src/: stm32f4xx_it.c main.cpp stm32f4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/ili9341/: ili9341.c
    ../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_hcd.c stm32f4xx_hal_cortex.c stm32f4xx_hal_hash.c stm32f4xx_hal_adc.c stm32f4xx_hal_pccard.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_dac.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_rtc.c stm32f4xx_hal_sram.c stm32f4xx_hal_pcd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_uart.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_i2s.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_hash_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_rng.c stm32f4xx_hal_sd.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_usart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_irda.c stm32f4xx_hal_cryp.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_rcc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_sai_ex.c
  group Example/MDK-ARM
    ./: startup_stm32f429xx.s
  group gui
    ../touchgfx/gui/src/common/scrollingwheels/: clickablecontainer.cpp particlesscrollingwheel.cpp scrollingmenu.cpp scrollingwheel.cpp sparsecontainerlist.cpp touchforwarder.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp particleeffect.cpp
    ../touchgfx/gui/src/main_screen/: mainpresenter.cpp mainview.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/screendimmer_screen/: screendimmerpresenter.cpp screendimmerview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp font_asap_regular_24_4bpp.cpp font_asap_regular_32_4bpp.cpp fontgetters.cpp kerning_asap_regular_24_4bpp.cpp kerning_asap_regular_32_4bpp.cpp table_asap_regular_24_4bpp.cpp table_asap_regular_32_4bpp.cpp
    ../touchgfx/generated/images/src/: background.cpp bitmapdatabase.cpp gotomenu.cpp particle00.cpp particle01.cpp particle02.cpp particle03.cpp particle04.cpp particle05.cpp particle06.cpp particle07.cpp particle08.cpp particle09.cpp particle10.cpp slider_knob_shape.cpp tgfx_shadow_logo.cpp wheel_selector_background.cpp wheel_selector_overlay.cpp
    ../touchgfx/generated/images/src/__designer/: blue_buttons_round_edge_small_pressed.cpp blue_slider_vertical_small_slider3_vertical_round_back.cpp blue_buttons_round_edge_small.cpp blue_slider_vertical_small_slider3_vertical_round_fill.cpp blue_togglebars_toggle_round_large_button_off.cpp blue_togglebars_toggle_round_large_button_on.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/main_screen/: mainviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screendimmer_screen/: screendimmerviewbase.cpp
  group os
    ../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group TouchGFX/Lib
    ../../middlewares/st/touchgfx/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group TouchGFX/Target
    ../TouchGFX/target/: OSWrappers.cpp BoardConfiguration.cpp CortexMMCUInstrumentation.cpp GPIO.cpp ResistiveTouchController.cpp STM32F4DMA.cpp STM32F4HAL.cpp CONSOL.cpp
  group AC_Dimmer_Library
    ../../Middlewares/AcDimmerLib/: dimmerlib.c dimmerTask.cpp dimmerFlash.c
    ./: not.txt not_2.txt
software components: CMSIS:CORE 5.0.0
